Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 1e86bd0c-c216-47d7-82b5-933aef67eed0, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-12T10:09:31+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12506040_D_DAS4620_MASW:28S4620M_D_12506040_DAS4620_MASW, (2)
In: Default
Type - Material: Výchozí Nový materiál, z_Miele_Design_Steel_Chrom, z_Miele_Design_Zinc_Steel, <Unnamed>, z_Miele_Design_CLST, Plast, z_Miele_Connection_Electric, z_Miele_Design_OBSW, z_Miele_Design_Cast, z_Miele_Design_GRGR
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 596 mm; Height: 436 mm; Depth: 273 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 28S4620M_D_12506040_DAS4620_MASW; sets with these values: 2

# IfcDistributionPort, Port_354661_1
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcOpeningElement: Opening, :1
In: Default
Classification: E1090320 Uniformat (Uniformat)
Pset_OpeningElementCommon - Reference: 28S4620M_D_12506040_DAS4620_MASW; sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment
